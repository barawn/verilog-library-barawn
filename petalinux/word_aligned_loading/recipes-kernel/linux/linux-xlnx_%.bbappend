FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fpga-zynqmp-Make-word-align-the-configuration-data.patch"

