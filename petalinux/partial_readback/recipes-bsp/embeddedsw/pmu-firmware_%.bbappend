FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://01_osu_hack_partial_readback_v8.patch"

EXTERNALXSCTSRC=""
EXTERNALXSCTSRC_BUILD = ""
