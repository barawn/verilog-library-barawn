FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-enable-efuse-access.patch"

EXTERNALXSCTSRC=""
EXTERNALXSCTSRC_BUILD = ""
